# Keil uVision project moto5.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NV32F100Fx32E Navota MCU
  pack: Keil.NV32F1x_DFP.1.2
  cpu: IRAM(0x1FFFF800,0x800) IRAM2(0x20000000,0x1800) IROM(0x00000000,0x20000) IROM2(0x00400000,0x1400) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: moto5
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL NV32 CMSIS DISABLE_NMI UARTCOM
  c include: .\common;.\cpu;.\lib;.\user;.\cpu\headers;.\drivers\delay;.\platforms
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x1400
  memory RVCT9: RAM 0x1ffff800 size 0x800
  memory RVCT10: RAM 0x20000000 size 0x1800
  group common
    ./common/: alloc.c assert.c io.c memtest.c queue.c stdlib.c
  group cpu
    ./cpu/: arm_cm0.c start.c sysinit.c systick.c vectors.c startup_NV32.s
  group drivers
    ./lib/: adc.c gpio.c ics.c kbi.c pit.c rtc.c sim.c uart.c wdog.c flash.c acmp.c crc.c eeprom.c i2c.c pmc.c spi.c etm.c
    ./drivers/delay/: delay.c
  group user
    ./user/: mcuconfig.c uartcom.c isrs.c moto5.c statemachine.c motokpiloop.c
